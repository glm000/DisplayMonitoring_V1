# Keil uVision project ScreenMonitor.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ScreenMonitor
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c misc: -Wno-invalid-utf8 -Wno-unsafe-buffer-usage -Wno-padded -Wno-missing-variable-declarations -Wno-implicit-int-conversion
  c include: .\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c
  group Hardware
    ./Hardware/: opt3001.h opt3001.c delay.c delay.h usart.c usart.h opt101.c opt101.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
